<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\..\..\Library\Project\IAR\NC199B-100.ewp</path>
  </project>
  <batchBuild/>
</workspace>


