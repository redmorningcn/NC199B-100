# IAR project NC199B-100.ewp, settings and files
configuration Debug-RC (ARM, debug)
  General.OGChipSelectEditMenu: STM32F107xC ST STM32F107xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; _STM32F10X_HD; STM32F10X_CL; DEBUG; STM32F103RC; STM32_FLASH_SIZE=256; HSE_VALUE=25000000
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\..\Source\APP; ..\..\Source\APP\User; ..\..\Source\APP\AES; ..\..\Source\APP\Config; ..\..\Source\APP\OS; ..\..\Source\APP\User; ..\..\Source\APP\SIM900A\Source; ..\..\Source\APP\SIM900A\Port; ..\..\Source\APP\SIM900A\OS; ..\..\Source\APP\SIM900A\Config; ..\..\Source\APP\Protocol; ..\..\Source\APP\Iap; ..\..\Source\BSP; ..\..\Source\BSP\Driver; ..\..\Source\BSP\IAR; ..\..\Source\BSP\Os; ..\..\Source\BSP\Os\uCOS-III; ..\..\Source\BSP\St; ..\..\Source\BSP\St\FWLib\CMSIS\CM3\CoreSupport; ..\..\Source\BSP\St\FWLib\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\..\Source\BSP\St\FWLib\STM32F10x_StdPeriph_Driver\inc; ..\..\Source\Micrium\uC-CPU; ..\..\Source\Micrium\uC-CPU\ARM-Cortex-M3\IAR; ..\..\Source\Micrium\uC-LIB; ..\..\Source\BSP\Os\OSAL; ..\..\Source\OSAL\OS; ..\..\Source\Micrium\uC-MB; ..\..\Source\Micrium\uC-MB\Cfg\Template; ..\..\Source\Micrium\uC-MB\OS\uCOS-III; ..\..\Source\Micrium\uC-MB\Source; ..\..\Source\Micrium\uC-OS-III; ..\..\Source\Micrium\uC-OS-III\Ports\ARM-Cortex-M3\Generic\IAR; ..\..\Source\Micrium\uC-OS-III\Source; ..\..\Source\FatFs; ..\..\Source\FatFs\option
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: NC014-001-000.CX_00_Debug-RC.bin
  ILINK.IlinkOutputFile: OS.out
  ILINK.IlinkIcfFile: ..\..\Source\BSP\IAR\STM32_Flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Debug-107C (ARM, debug)
  as the first configuration, except:
configuration Relase-107C-APP (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_CL; RELEASE; IMAGE_A; STM32F103RC; STM32_FLASH_SIZE=256; HSE_VALUE=25000000
  OBJCOPY.OOCOutputFile: NC199B-100-000.CX_APP_Release.bin
  ILINK.IlinkIcfFile: F:\iar\NC199B-100\Library\Source\BSP\IAR\STM32_Flash_A.icf
configuration Debug-107C-APP (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_CL; DEBUG; IMAGE_A; STM32F103RC; STM32_FLASH_SIZE=256; HSE_VALUE=25000000
  OBJCOPY.OOCOutputFile: NC199B-100-000.CX_APP_Debug.bin
  ILINK.IlinkIcfFile: F:\iar\NC199B-100\Library\Source\BSP\IAR\STM32_Flash_A.icf
  group (top)
    ../../../Project/IAR/: readme.txt
    ./: UpdateLog.log
  group APP
    ../../Source/APP/: main.c
  group APP/Aes
    ../../Source/APP/AES/: aes.h aes_cbc.c aes_cfb.c aes_core.c aes_ctr.c aes_ecb.c aes_ige.c aes_locl.h aes_misc.c aes_ofb.c aes_user.c aes_wrap.c
  group APP/Config
    ../../Source/APP/Config/: app_cfg.h cpu_cfg.h lib_cfg.h os_cfg.h os_cfg_app.h stm32f10x_conf.h
  group APP/IAP
    ../../Source/APP/Iap/: boot.c iap_flash.c
  group APP/OS
    ../../Source/APP/OS/: os_app_hooks.c os_app_hooks.h
  group APP/Tasks
    ../../../../NC199B-200 主板/Software/APP/comm/: app_comm_dtu.c app_comm_dtu_otr_deal.c app_comm_mtr.c
    ../../Source/APP/Tasks/: app_task_comm.c app_task_measure.c app_task_osal.c app_task_osal_disp.c app_task_osal_led.c APP_task_osal_mtrsend.c APP_task_osal_store.c app_task_osal_tmr.c
    ../../Source/APP/Iap/: IAP_program_mcu.C IAP_program_mcu.h
  group APP/Tasks/Protocol
    ../../Source/APP/Protocol/: app_chk.c app_comm_protocol.c app_comm_protocol.h Protocol.h
  group APP/User
    ../../Source/APP/User/: app.c app.h app_ctrl.h app_lib.c app_lib.h app_tax.c app_tax.h app_var.c csnc_package_deal.c csnc_package_deal.h global.h includes.h sprintf.c
  group BSP/Driver/Board
    ../../Source/BSP/Driver/: bsp_DM412.c bsp_DM412.h bsp_ds3231.c bsp_ds3231.h bsp_FRAM.c bsp_FRAM.h bsp_IIC.c bsp_IIC.h bsp_max7219.c bsp_max7219.h MX25L1602Drv.c MX25L1602Drv.h
  group BSP/Driver/Mater
    ../../Source/BSP/Driver/: config.h delay.c delay.h Display.c Display.h FM24CL64.c FM24CL64.h I2C_CLK.c I2C_CLK.h RS485.c RS485.h stc_AirDef.h stc_ProCommDef .h
  group BSP/Driver/Mcu
    ../../Source/BSP/Driver/: bsp_flash.c bsp_flash.h bsp_gpio.c bsp_gpio.h bsp_info.c bsp_info.h bsp_pwm.c bsp_pwm.h bsp_rst.c bsp_rst.h bsp_rtc.c bsp_rtc.h bsp_time.c bsp_time.h bsp_usart.c bsp_usart.h bsp_wdt.c bsp_wdt.h
  group BSP/IAR
    ../../Source/BSP/IAR/: cstartup.c STM32_Flash.icf STM32_Flash_A.icf STM32_Flash_B.icf
  group BSP/OS
    ../../Source/BSP/OS/uCOS-III/: bsp_os.c bsp_os.h
  group BSP/OSAL/OS
    ../../Source/OSAL/OS/: osal.c osal.h osal_cpu.h osal_event.c osal_event.h osal_memory.c osal_memory.h osal_timer.c osal_timer.h
  group BSP/OSAL/Ports
    ../../Source/BSP/OS/OSAL/: bsp_hal.c bsp_hal.h bsp_timer.c bsp_timer.h
  group BSP/ST/FWLib/CMSIS
    ../../Source/BSP/ST/FWLib/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../../Source/BSP/ST/FWLib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group BSP/ST/FWLib/inc
    ../../Source/BSP/ST/FWLib/STM32F10x_StdPeriph_Driver/inc/: misc.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_cec.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h stm32f10x_wwdg.h
  group BSP/ST/FWLib/src
    ../../Source/BSP/ST/FWLib/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group BSP/User
    ../../Source/BSP/: bsp.c bsp.h bsp_int.c bsp_periph.c
  group uC/CPU
    ../../Source/Micrium/uC-CPU/: cpu_core.c cpu_core.h cpu_def.h
  group uC/CPU/IAR
    ../../Source/Micrium/uC-CPU/ARM-Cortex-M3/IAR/: cpu.h cpu_a.asm cpu_c.c
  group uC/LIB
    ../../Source/Micrium/uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
  group uC/LIB/Ports
    ../../Source/Micrium/uC-LIB/Ports/ARM-Cortex-M3/IAR/: lib_mem_a.asm
  group uC/MB/Cfg
    ../../Source/Micrium/uC-MB/Cfg/Template/: mb_app_hooks.c mb_app_hooks.h mb_cfg.h MB_DATA.C
  group uC/MB/Os/uCOS-III
    ../../Source/Micrium/uC-MB/OS/uCOS-III/: MB_OS.C MB_OS.H
  group uC/MB/Ports
    ../../Source/Micrium/uC-MB/Ports/STM32/STM32F103/IAR/: MB_BSP.C
  group uC/MB/Source
    ../../Source/Micrium/uC-MB/Source/: MB.C MB.h MB_AES.C MB_DEF.H MB_UTIL.C MBM_CORE.C MBS_CORE.C
  group uC/OS-III/Port
    ../../Source/Micrium/uC-OS-III/Ports/ARM-Cortex-M3/Generic/IAR/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group uC/OS-III/Source
    ../../Source/Micrium/uC-OS-III/Source/: os.h os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_type.h os_var.c
